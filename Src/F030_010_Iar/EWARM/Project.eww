<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F030_010.ewp</path>
  </project>
  <batchBuild />
</workspace>
